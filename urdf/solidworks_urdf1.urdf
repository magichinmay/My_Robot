Commit message: real_robot

File: urdf/solidworks_urdf1.urdf (robot description, URDF)
Before this commit: robot my_robot, 7 links, 6 joints
Links:
- removed link base_footprint
Joints:
- removed joint base_footprint_joint
